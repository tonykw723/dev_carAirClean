# Keil uVision project lib_freertos.uvproj, settings and files
target libfreertos (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: lib_freertos +hex (library)
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_MD
  c include: ..\..\..\..\bsp\platform\arm-m3-stm32l1xx\CMSIS\Include;..\..\..\..\bsp\platform\arm-m3-stm32l1xx\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\..\bsp\platform\arm-m3-stm32l1xx\STM32L1xx_StdPeriph_Driver\inc;..\..\..\..\bsp\broad\rtu09c\app\stm32l1xx;..\..\..\..\lib\AES;..\..\..\..\prj\crossfire\app;..\..\..\..\src\drv;..\..\..\..\thirdparty\FreeRTOSV7.5.2\FreeRTOS\Source\include;..\..\..\..\bsp\broad\rtu09c\app;..\..\..\..\thirdparty\FreeRTOSV7.5.2\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\..\inc\os
  memory RVCT4: ROM 0x8002000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3c00
  memory RVCT10: RAM 0x20003c00 size 0x400
  group src
    ../../../../thirdparty/FreeRTOSV7.5.2/FreeRTOS/Source/: timers.c croutine.c list.c queue.c tasks.c
    ../../../../thirdparty/FreeRTOSV7.5.2/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../../../thirdparty/FreeRTOSV7.5.2/FreeRTOS/Source/portable/MemMang/: heap_2.c
