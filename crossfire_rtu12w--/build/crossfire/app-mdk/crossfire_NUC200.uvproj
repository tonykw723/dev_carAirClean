# Keil uVision project crossfire_NUC200.uvproj, settings and files
target crossfire (ARM-ADS)
  device: NUC200VE3AN Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: crossfire +hex
  AfterMake: fromelf --bin ".\out\@L.axf" --output ".\out\@L.bin"
  AfterMake: fromelf --text -c ".\out\@L.axf" --output ".\out\@L.txt"
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,NUVOTON_NUC200
  c include: ..\..\..\bsp\platform\arm-m0-nuc200\CMSIS\CM0\CoreSupport;..\..\..\bsp\platform\arm-m0-nuc200\StdDriver\inc;..\..\..\bsp\broad\rtu09c\app;..\..\..\bsp\broad\rtu09c\app\nuc200;..\..\..\thirdparty\FreeRTOSV7.5.2\FreeRTOS\Source\include;..\..\..\thirdparty\FreeRTOSV7.5.2\FreeRTOS\Source\portable\RVDS\ARM_CM0;..\..\..\thirdparty\Unity-master\src;..\..\..\inc;..\..\..\inc\ap;..\..\..\inc\drv;..\..\..\inc\mdl;..\..\..\inc\os;..\..\..\inc\util;..\..\..\prj\crossfire\app;..\..\..\util
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --first='startup_NUC200Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group bsp-broad
    ../../../bsp/broad/rtu09c/app/: xt_bsp_rtu09c.c
    ../../../bsp/broad/rtu09c/app/nuc200/: Initialization.c system_NUC200Series.c startup_NUC200Series.s
  group bsp-platform
    ../../../bsp/platform/arm-m0-nuc200/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../bsp/platform/arm-m0-nuc200/StdDriver/src/: retarget.c
  group lib-freertos
    ../../../thirdparty/FreeRTOSV7.5.2/FreeRTOS/Source/: timers.c croutine.c list.c queue.c tasks.c
    ../../../thirdparty/FreeRTOSV7.5.2/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../thirdparty/FreeRTOSV7.5.2/FreeRTOS/Source/portable/RVDS/ARM_CM0/: port.c
  group prj
    ../../../prj/crossfire/app/: main.c config.c
  group test
    ../../../thirdparty/Unity-master/src/: unity.c
    ../../../test/crossfire/app/: test_main.c
  group src-ap
    ../../../src/ap/: ap_comm.c ap_rtu.c ap_measure.c misc_timer.c
  group src-mdl
    ../../../src/mdl/dev/risecomm/: dev_rise.c
    ../../../src/mdl/pro/iotcomm/: pro_ap_iot.c pro_dev_iot.c
    ../../../src/mdl/pro/huazhi/: pro_ap_hz.c
    ../../../src/mdl/conn/: conn_msg.c
  group src-os
    ../../../src/os/: xtos_print.c
  group src-util
    ../../../src/util/: ringqueue.c
