# Keil uVision project crossfire_L1xx_SM4.uvproj, settings and files
target crossfire (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: crossfire +hex
  BeforeMake: .\beforebuild.bat
  AfterMake: .\afterbuild_SM4.bat
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32L1XX_MD,ENCRY_LIB_SM4
  c include: ..\..\..\bsp\platform\arm-m3-stm32l1xx\CMSIS\Include;..\..\..\bsp\platform\arm-m3-stm32l1xx\CMSIS\Device\ST\STM32L1xx\Include;..\..\..\bsp\platform\arm-m3-stm32l1xx\STM32L1xx_StdPeriph_Driver\inc;..\..\..\bsp\broad\rtu09c\app;..\..\..\bsp\broad\rtu09c\app\stm32l1xx;..\..\..\thirdparty\FreeRTOSV7.5.2\FreeRTOS\Source\include;..\..\..\thirdparty\FreeRTOSV7.5.2\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\thirdparty\Unity-master\src;..\..\..\inc;..\..\..\inc\ap;..\..\..\inc\drv;..\..\..\inc\mdl;..\..\..\inc\os;..\..\..\inc\util;..\..\..\prj\crossfire\app;..\..\..\util;..\..\..\lib\AES;..\..\..\src\drv;..\..\..\src\mdl\data_manager
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group bsp-broad
    ../../../bsp/broad/rtu09c/app/: xt_bsp_rtu09c.c
    ../../../bsp/broad/rtu09c/app/stm32l1xx/: discover_board.c stm32l1xx_it.c system_stm32l1xx.c startup_stm32l1xx_mdp.s I2C_M24LR04E-R.c I2C_AT24LCxxx.c
  group bsp-platform
    ../../../bsp/platform/arm-m3-stm32l1xx/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group lib-freertos
    ../../../thirdparty/FreeRTOSV7.5.2/FreeRTOS/Source/: timers.c croutine.c list.c queue.c tasks.c
    ../../../thirdparty/FreeRTOSV7.5.2/FreeRTOS/Source/portable/MemMang/: heap_2.c
    ../../../thirdparty/FreeRTOSV7.5.2/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group prj
    ../../../prj/crossfire/app/: main.c config.c
  group test
    ../../../thirdparty/Unity-master/src/: unity.c
    ../../../test/crossfire/app/: test_main.c
  group src-ap
    ../../../src/ap/: ap_comm.c ap_rtu.c ap_measure.c misc_timer.c
  group src-mdl
    ../../../src/mdl/dev/risecomm/: dev_rise.c
    ../../../src/mdl/pro/iotcomm/: pro_ap_iot.c pro_dev_iot.c
    ../../../src/mdl/pro/huazhi/: pro_ap_hz.c
    ../../../src/mdl/conn/: conn_msg.c
    ../../../src/mdl/dev/solar_controller/: dev_solar_controller.c dev_solar_phili.c dev_solar_yuanfang.c dev_solar_huineng.c
    ../../../src/mdl/dev/zigbee_shunzhou/: dev_zigbee_shunzhou.c
    ../../../src/mdl/data_manager/: solar_data_manager.c
    ../../../src/mdl/dev/zigbee_digi/: dev_zigbee_digi.c
  group src-os
    ../../../src/os/: xtos_print.c
  group src-util
    ../../../src/util/: ringqueue.c utils.c
  group lib-aes
    ../libSTAES/mdk/out/: lib_aes.lib
  group src-drv
    ../../../src/drv/: smartcard.c
