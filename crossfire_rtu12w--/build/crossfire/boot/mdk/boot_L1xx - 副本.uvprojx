# Keil uVision project boot_L1xx - 副本.uvprojx, settings and files
target boot (ARM-ADS)
  device: STM32L152RB STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: boot +hex
  AfterMake: .\afterbuild.bat
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32L1XX_MD
  c include: ..\..\..\..\prj\crossfire\boot;..\..\..\..\bsp\broad\rtu09c\boot\stm32l1xx;..\..\..\..\bsp\broad\rtu09c\app\stm32l1xx;..\..\..\..\bsp\platform\arm-m3-stm32l1xx\STM32L1xx_StdPeriph_Driver\inc;..\..\..\..\bsp\platform\arm-m3-stm32l1xx\CMSIS\Include;..\..\..\..\prj\crossfire\app;..\..\..\..\thirdparty\FreeRTOSV7.5.2\FreeRTOS\Source\include;..\..\..\..\bsp\broad\rtu09c\app;..\..\..\..\thirdparty\FreeRTOSV7.5.2\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\..\..\bsp\platform\arm-m3-stm32l1xx\CMSIS\Device\ST\STM32L1xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x2000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../../../../prj/crossfire/boot/: main.c ymodem.c common.c
    ../../../../bsp/broad/rtu09c/boot/stm32l1xx/: stm32l1xx_it.c system_stm32l1xx.c startup_stm32l1xx_mdp.s discover_board.c
    ../../../../bsp/broad/rtu09c/app/stm32l1xx/: I2C_M24LR04E-R.c
  group stm32
    ../../../../bsp/platform/arm-m3-stm32l1xx/STM32L1xx_StdPeriph_Driver/src/: stm32l1xx_rcc.c stm32l1xx_syscfg.c stm32l1xx_usart.c misc.c stm32l1xx_dbgmcu.c stm32l1xx_exti.c stm32l1xx_gpio.c stm32l1xx_pwr.c stm32l1xx_rtc.c stm32l1xx_dma.c stm32l1xx_i2c.c stm32l1xx_flash.c
